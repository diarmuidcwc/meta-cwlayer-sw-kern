FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://linux-imx.patch"
SRC_URI += "file://fragment.cfg"




